DESCRIPTION = "Critical hello application"
SECTION = "NetileCorp"
LICENSE = "custom"

LIC_FILES_CHKSUM = "file://LICENSE;md5=8e310913496256626baccb51dc24cead"

PR = "r8"

SRC_URI = "file:///home/diger/helloSoft"
S = "${WORKDIR}/helloSoft"


